# IAR project Test1.0.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 2
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..\Stdriver\inc; ..\User
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: LightDrv1.1.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group Stdriver
    ../Stdriver/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group User
    ../User/: LightRGBWDrv.c main.c ProtocolParser.c stm8s_conf.h stm8s_it.c Uart1Dev.c user_flash.c
